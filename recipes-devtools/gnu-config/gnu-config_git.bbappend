SRCREV = "428664896cf9e92d264976a960c76660938dffce"

SRC_URI = "git://git.codelinaro.org/clo/yocto-mirrors/config.git;protocol=https;branch=master \
           file://gnu-configize.in"
