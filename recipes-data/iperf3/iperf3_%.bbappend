FILESEXTRAPATHS:append := ":${THISDIR}/files"