linux-qcom-custom_6.6.bbappend